## src/Kconfig.projbuild
```kconfig
config I2CDEV_TIMEOUT
    int "I2C transaction timeout, milliseconds"
    default 1000
    range 10 5000
```
